<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gr_vector_sink_x</key>
<param><key>id</key><value>gr_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>140</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>(0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,1)</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>140</value></param>
</block>
<block>
<key>scimod_dsim</key>
<param><key>id</key><value>scimod_dsim_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>140</value></param>
<param><key>n0</key><value>1</value></param>
<param><key>n1</key><value>1</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>d0</key><value>2</value></param>
<param><key>d1</key><value>1</value></param>
<param><key>window</key><value>140</value></param>
</block>
<block>
<key>extras_subtract</key>
<param><key>id</key><value>extras_subtract_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>140</value></param>
<param><key>preload</key><value>1</value></param>
</block>
<block>
<key>scimod_generic</key>
<param><key>id</key><value>scimod_generic_0</value></param>
<param><key>type</key><value>fc32_fc32</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>n0</key><value>0</value></param>
<param><key>n1</key><value>0</value></param>
<param><key>step</key><value>0</value></param>
<param><key>d0</key><value>0</value></param>
<param><key>d1</key><value>0</value></param>
<param><key>window</key><value>0</value></param>
</block>
<connection><source_block_id>scimod_dsim_0</source_block_id><sink_block_id>gr_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>extras_subtract_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_subtract_0</source_block_id><sink_block_id>scimod_dsim_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>scimod_dsim_0</source_block_id><sink_block_id>extras_subtract_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
